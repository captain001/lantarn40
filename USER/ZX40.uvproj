# Keil uVision project ZX40.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 40-low2-BMW +hex
  AfterMake: D:\Keil\ARM\bin\fromelf.exe --bin -o ..\RH-NEW.bin  ..\OBJ\RH-NEW.axf
  c flags: Optim=2
  c define: STM32F10X_MD
  c include: ..\SYSTEM;..\USER;..\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c led.c export.c hb.c wifi_init.c
  group SYSTEM
    ../SYSTEM/: CH374HFT.C clock.c flash.c stmlib.c CH374HFM.LIB
  group CORE
    ../CORE/: startup_stm32f10x_md.s
  group New Group
    ./: 维护说明.txt
